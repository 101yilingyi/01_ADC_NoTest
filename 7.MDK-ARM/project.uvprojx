# Keil uVision project project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xE,USE_HAL_DRIVER
  c include: ..\1.Applications;..\2.Protocols;..\3.Middlewares;..\4.Modules;..\5.Peripherals;..\6.HAL_Driver;..\6.HAL_Driver\CMSIS\Include;..\6.HAL_Driver\STM32F1xx_HAL_Driver\Inc;..\6.HAL_Driver\CMSIS;..\3.Middlewares\FreeRTOS\include;..\3.Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\3.Middlewares\FreeRTOS;..\3.Middlewares\RingBuffer;..\5.Peripherals\Inc;..\4.Modules\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group 1.Applications
    ../1.Applications/: main.c
  group 3.Middlewares
    ../3.Middlewares/RingBuffer/: RingBuffer.c
  group 3.Middlewares/FreeRTOS
    ../3.Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../3.Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../3.Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group 4.Modules
    ../4.Modules/: drv_rs485.c drv_net.c drv_vm501.c
  group 5.Peripherals
    ../5.Peripherals/: stm32f1xx_it.c stm32f1xx_hal_timebase_tim.c drv_gpio.c drv_adc.c drv_i2c.c drv_uart.c drv_sw_i2c.c drv_flash.c
  group 6.HAL_Driver
    ../6.HAL_Driver/CMSIS/: system_stm32f1xx.c
    ../6.HAL_Driver/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_sdmmc.c
  group 7.MDK-ARM
    ../6.HAL_Driver/CMSIS/: startup_stm32f103xe.s
